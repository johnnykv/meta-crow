FILESEXTRAPATHS_prepend := "${THISDIR}/initscripts:"
#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
