module_autoload_nls-utf8 = "nls-utf8"
module_autoload_nls-iso8859-1 = "nls-iso8859-1"
module_autoload_nls-cp437 = "nls-cp437"
